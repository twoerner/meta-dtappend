FILESEXTRAPATHS:prepend := "${THISDIR}/dtappend:"
inherit dtappend
